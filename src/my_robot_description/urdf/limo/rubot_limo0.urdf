Commit message: limo camera

File: src/my_robot_description/urdf/limo/rubot_limo0.urdf (robot description, URDF)
Before this commit: robot limo, 9 links, 8 joints
Links:
- link part: geometry collision box size=0.05 0.05 0.025; visual box size=0.05 0.05 0.010
